options:
  parameters:
    author: Mayur Ware
    generate_options: qt_gui
    id: lab9_6
    output_language: python
    title: Lab 9 Part 6
  states: {}

blocks:
- name: const_points
  id: variable
  parameters:
    value: '4'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.4'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: ntaps
  id: variable
  parameters:
    value: 11*nfilts*sps
  states: {}
- name: rx_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0, excess_bw, ntaps)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: samp_rate_2
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: timing_bw
  id: variable
  parameters:
    value: 2*pi/100
  states: {}
- name: tx_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0, excess_bw, ntaps)
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '8'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 10e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '100'
    type: float
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {}
- name: blocks_delay_1_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.125'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.125'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_2
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_2_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_2_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_3_0
  id: blocks_multiply_xx
  parameters:
    num_inputs: '4'
    type: complex
  states: {}
- name: blocks_multiply_xx_3_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_3_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_3_0_1
  id: blocks_multiply_xx
  parameters:
    num_inputs: '4'
    type: complex
  states: {}
- name: blocks_throttle_1_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate/4
    type: complex
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '12345'
    psize: '1472'
    type: float
    vlen: '1'
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '12345'
    psize: '1472'
    type: float
    vlen: '1'
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate/4
    sensitivity: '-samp_rate/4'
  states: {}
- name: blocks_vco_c_0_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate/4
    sensitivity: '-5'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[sqrt(0.5), 0.5+0.5j, sqrt(0.5)*1j, -0.5+0.5j, -sqrt(0.5), -0.5-0.5j, -sqrt(0.5)*1j, 0.5-0.5j]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: '16'
    loop_bw: timing_bw
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rx_taps
    type: ccf
  states: {}
- name: iir_filter_xxx_0
  id: iir_filter_xxx
  parameters:
    fbtaps: '[-1,0.99]'
    fftaps: '[0.01]'
    type: ffd
  states: {}
- name: iir_filter_xxx_1
  id: iir_filter_xxx
  parameters:
    fbtaps: '[-1,1]'
    fftaps: '[1.0001,-1]'
    type: ffd
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: from gnuradio import filter
  states: {}
- name: import_0_0_0_0
  id: import
  parameters:
    imports: from math import sqrt
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: sps
    taps: tx_taps
    type: ccf
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/4
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_arg_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_arg_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_2, '1']
- [blocks_conjugate_cc_0_0, '0', blocks_multiply_xx_2_1, '0']
- [blocks_delay_0, '0', iir_filter_xxx_1, '0']
- [blocks_delay_1, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_1_0, '0', blocks_conjugate_cc_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_vco_c_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', iir_filter_xxx_0, '0']
- [blocks_multiply_xx_0, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [blocks_multiply_xx_1, '0', blocks_multiply_xx_2_0, '0']
- [blocks_multiply_xx_2, '0', blocks_complex_to_arg_0, '0']
- [blocks_multiply_xx_2_0, '0', blocks_multiply_xx_3_0_1, '0']
- [blocks_multiply_xx_2_0, '0', blocks_multiply_xx_3_0_1, '1']
- [blocks_multiply_xx_2_0, '0', blocks_multiply_xx_3_0_1, '2']
- [blocks_multiply_xx_2_0, '0', blocks_multiply_xx_3_0_1, '3']
- [blocks_multiply_xx_2_0, '0', blocks_throttle_1_0, '0']
- [blocks_multiply_xx_2_1, '0', blocks_complex_to_arg_0_0, '0']
- [blocks_multiply_xx_3_0, '0', blocks_multiply_xx_3_0_0, '0']
- [blocks_multiply_xx_3_0, '0', blocks_multiply_xx_3_0_0, '1']
- [blocks_multiply_xx_3_0_0, '0', blocks_delay_1, '0']
- [blocks_multiply_xx_3_0_0, '0', blocks_multiply_xx_2, '0']
- [blocks_multiply_xx_3_0_0_0, '0', blocks_delay_1_0, '0']
- [blocks_multiply_xx_3_0_0_0, '0', blocks_multiply_xx_2_1, '1']
- [blocks_multiply_xx_3_0_1, '0', blocks_multiply_xx_3_0_0_0, '0']
- [blocks_multiply_xx_3_0_1, '0', blocks_multiply_xx_3_0_0_0, '1']
- [blocks_throttle_1_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_udp_source_0, '0', blocks_delay_0, '0']
- [blocks_vco_c_0, '0', blocks_multiply_xx_1, '1']
- [blocks_vco_c_0_0, '0', blocks_multiply_xx_2_0, '1']
- [digital_chunks_to_symbols_xx_0, '0', pfb_arb_resampler_xxx_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', blocks_multiply_xx_1, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', blocks_multiply_xx_3_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', blocks_multiply_xx_3_0, '1']
- [digital_pfb_clock_sync_xxx_0_0, '0', blocks_multiply_xx_3_0, '2']
- [digital_pfb_clock_sync_xxx_0_0, '0', blocks_multiply_xx_3_0, '3']
- [iir_filter_xxx_0, '0', blocks_udp_sink_0, '0']
- [iir_filter_xxx_1, '0', blocks_vco_c_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
