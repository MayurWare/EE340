options:
  parameters:
    generate_options: qt_gui
    id: part4
    output_language: python
    title: Part 4
  states: {}

blocks:
- name: SampleRate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: SampleRate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: E:\Lab 1\Audio Files\shor.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '2500'
    decim: '1'
    gain: '1'
    samp_rate: SampleRate
    type: fir_filter_fff
    width: '150'
    win: firdes.WIN_HAMMING
  states: {}

connections:
- [blocks_wavfile_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
