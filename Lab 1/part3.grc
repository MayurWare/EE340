options:
  parameters:
    generate_options: qt_gui
    id: part3
    output_language: python
    title: Part 3
  states: {}

blocks:
- name: Adjust_0
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.5'
  states: {}
- name: Adjust_1
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.5'
  states: {}
- name: Adjust_2
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.5'
  states: {}
- name: Adjust_3
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.5'
  states: {}
- name: Adjust_4
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.5'
  states: {}
- name: SampleRate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: SampleRate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: Adjust_3
    high_cutoff_freq: '9000'
    low_cutoff_freq: '6000'
    samp_rate: SampleRate
    type: fir_filter_fff
    width: '1'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: Adjust_4
    high_cutoff_freq: '15000'
    low_cutoff_freq: '9000'
    samp_rate: SampleRate
    type: fir_filter_fff
    width: '1'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_2
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: Adjust_0
    high_cutoff_freq: '500'
    low_cutoff_freq: '20'
    samp_rate: SampleRate
    type: fir_filter_fff
    width: '1'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_3
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: Adjust_1
    high_cutoff_freq: '3000'
    low_cutoff_freq: '500'
    samp_rate: SampleRate
    type: fir_filter_fff
    width: '1'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_4
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: Adjust_2
    high_cutoff_freq: '6000'
    low_cutoff_freq: '3000'
    samp_rate: SampleRate
    type: fir_filter_fff
    width: '1'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: SampleRate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: E:\Lab 1\Audio Files\Bach.wav
    repeat: 'True'
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_add_xx_0, '1']
- [band_pass_filter_1, '0', blocks_add_xx_0, '3']
- [band_pass_filter_2, '0', blocks_add_xx_0, '0']
- [band_pass_filter_3, '0', blocks_add_xx_0, '2']
- [band_pass_filter_4, '0', blocks_add_xx_0, '4']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_1, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_2, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_3, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_4, '0']

metadata:
  file_format: 1
